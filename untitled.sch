v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/vsource.sym} 30 -40 2 0 {name=V2 value="PULSE(0.2 0.8 1ns 100ps 100ps 120ns 240ns )"}
C {devices/vsource.sym} 110 -50 2 0 {name=V1 value="PULSE(0.2 0.8 1ns 100ps 100ps 120ns 240ns )"}
C {devices/vsource.sym} 130 60 0 0 {name=V3 value="0.5 AC 0.5"
only_toplevel=true}
C {devices/vsource.sym} -290 -570 2 0 {name=V4 value="PULSE(0.2 0.8 1ns 100ps 100ps 120ns 240ns )"}
